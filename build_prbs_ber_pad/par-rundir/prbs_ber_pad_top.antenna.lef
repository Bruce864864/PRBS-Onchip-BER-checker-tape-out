

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
NAMESCASESENSITIVE ON ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO prbs_ber_pad_top 
  PIN clk 
    ANTENNADIFFAREA 0.4074 LAYER METAL4 ; 
    ANTENNAPARTIALMETALAREA 81.2322 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 154.458 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.656 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 201.137 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 384.241 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 0.308676 LAYER VIA45 ;
  END clk
  PIN rst_n 
    ANTENNAPARTIALMETALAREA 4.4506 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 17.1455 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3285 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 107.32 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 409.834 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0676 LAYER VIA45 ;
    ANTENNAMAXCUTCAR 1.02892 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 30.0608 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 114.989 LAYER METAL5 ;
    ANTENNAGATEAREA 0.7551 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 147.13 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 562.117 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 1.02892 LAYER VIA56 ;
  END rst_n
  PIN ext_serial_in 
    ANTENNAPARTIALMETALAREA 5.0554 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 19.4351 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0676 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 4.6536 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 17.914 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2133 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 41.9081 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 165.609 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 1.2677 LAYER VIA56 ;
  END ext_serial_in
  PIN cfg_sclk 
    ANTENNAPARTIALMETALAREA 28.3374 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 107.574 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0676 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.203 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.0653 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0676 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 4.6536 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 17.914 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2133 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 37.0511 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 145.831 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 0.950774 LAYER VIA45 ;
  END cfg_sclk
  PIN cfg_cs_n 
    ANTENNAPARTIALMETALAREA 24.2606 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 92.1405 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4266 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 61.7689 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 238.053 LAYER METAL2 ;
    ANTENNAMAXCUTCAR 0.158462 LAYER VIA23 ;
  END cfg_cs_n
  PIN cfg_mosi 
    ANTENNAPARTIALMETALAREA 26.9052 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 101.855 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4266 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 63.8261 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 241.817 LAYER METAL2 ;
    ANTENNAMAXCUTCAR 0.158462 LAYER VIA23 ;
  END cfg_mosi
  PIN cfg_miso 
    ANTENNAPARTIALMETALAREA 24.9382 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 94.4089 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0676 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.2632 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.2932 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0676 LAYER VIA34 ;
    ANTENNADIFFAREA 1.1676 LAYER METAL4 ; 
    ANTENNAPARTIALMETALAREA 5.908 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 22.6628 LAYER METAL4 ;
  END cfg_miso
  PIN busy 
    ANTENNADIFFAREA 1.1376 LAYER METAL4 ; 
    ANTENNAPARTIALMETALAREA 59.8962 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 227.937 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.331 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 93.7835 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 362.907 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 0.988128 LAYER VIA45 ;
  END busy
  PIN core_en 
    ANTENNADIFFAREA 1.1376 LAYER METAL4 ; 
    ANTENNAPARTIALMETALAREA 59.8178 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 227.343 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.331 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 25.6619 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 97.5305 LAYER METAL4 ;
  END core_en
  PIN done 
    ANTENNAPARTIALMETALAREA 56.966 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 216.251 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.6002 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 47.1107 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 179.531 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0676 LAYER VIA45 ;
    ANTENNAMAXCUTCAR 0.547476 LAYER VIA45 ;
    ANTENNADIFFAREA 1.1376 LAYER METAL5 ; 
    ANTENNAPARTIALMETALAREA 35.3864 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 134.26 LAYER METAL5 ;
    ANTENNAGATEAREA 1.8135 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 66.6235 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 253.565 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 1.2677 LAYER VIA56 ;
  END done
  PIN prbs_out 
    ANTENNADIFFAREA 1.2198 LAYER METAL4 ; 
    ANTENNAPARTIALMETALAREA 38.9928 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 147.912 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.2375 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 84.8561 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 323.553 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 0.688475 LAYER VIA45 ;
  END prbs_out
  PIN ref_bit 
    ANTENNADIFFAREA 1.2198 LAYER METAL4 ; 
    ANTENNAPARTIALMETALAREA 38.9536 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 147.467 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.2375 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 31.4777 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 119.165 LAYER METAL4 ;
  END ref_bit
  PIN bit_error 
    ANTENNADIFFAREA 1.2798 LAYER METAL4 ; 
    ANTENNAPARTIALMETALAREA 43.1662 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 164.008 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.3796 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 76.0214 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 290.165 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 1.03 LAYER VIA45 ;
  END bit_error
  PIN checker_in 
    ANTENNADIFFAREA 1.2198 LAYER METAL4 ; 
    ANTENNAPARTIALMETALAREA 3.934 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.893 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.8865 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 70.478 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 274.339 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 0.710104 LAYER VIA45 ;
  END checker_in
  PIN checker_in_final 
    ANTENNAPARTIALMETALAREA 7.4298 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 28.4239 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0676 LAYER VIA45 ;
    ANTENNADIFFAREA 1.1582 LAYER METAL5 ; 
    ANTENNAPARTIALMETALAREA 3.7128 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 14.3524 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.8532 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 110.691 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 424.652 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 1.34693 LAYER VIA56 ;
  END checker_in_final
  PIN cfg_we_dbg 
    ANTENNAPARTIALMETALAREA 28.231 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 106.874 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0676 LAYER VIA23 ;
    ANTENNADIFFAREA 1.1376 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 12.2864 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 47.1064 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.0872 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 48.8092 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 187.482 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 0.475387 LAYER VIA34 ;
  END cfg_we_dbg
  PIN cfg_re_dbg 
    ANTENNAPARTIALMETALAREA 27.447 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 103.906 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0676 LAYER VIA23 ;
    ANTENNADIFFAREA 1.1376 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 24.9368 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 95.294 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.7064 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 68.2007 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 260.614 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 0.950774 LAYER VIA34 ;
  END cfg_re_dbg
  PIN mode_select_dbg 
    ANTENNAPARTIALMETALAREA 12.7078 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 48.1081 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0676 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 58.1224 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 220.332 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0676 LAYER VIA34 ;
    ANTENNADIFFAREA 1.0044 LAYER METAL4 ; 
    ANTENNAPARTIALMETALAREA 63.4536 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 240.514 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.8532 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 88.7793 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 341.44 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 0.950774 LAYER VIA45 ;
  END mode_select_dbg
  PIN input_select_dbg 
    ANTENNAPARTIALMETALAREA 12.0806 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 45.7337 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0676 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 29.428 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 111.703 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0676 LAYER VIA34 ;
    ANTENNADIFFAREA 1.1376 LAYER METAL4 ; 
    ANTENNAPARTIALMETALAREA 61.3648 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 232.903 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.4931 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 91.9803 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 352.432 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 1.2677 LAYER VIA45 ;
  END input_select_dbg
  PIN inject_error_enable_dbg 
    ANTENNAPARTIALMETALAREA 40.775 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 154.363 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0676 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.5768 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.4804 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0676 LAYER VIA34 ;
    ANTENNADIFFAREA 1.1376 LAYER METAL4 ; 
    ANTENNAPARTIALMETALAREA 45.3712 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 172.356 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.0665 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 57.8778 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 223.43 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 1.2677 LAYER VIA45 ;
  END inject_error_enable_dbg
END prbs_ber_pad_top

END LIBRARY
